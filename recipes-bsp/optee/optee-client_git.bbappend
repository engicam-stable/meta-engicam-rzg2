COMPATIBLE_MACHINE = "(ek874|hihope-rzg2m|hihope-rzg2n|icorerz2ge)"
