FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

SRC_URI_append = " \
     file://gstvspfilter-icorerz2ge_r8a774c0.conf \
"
